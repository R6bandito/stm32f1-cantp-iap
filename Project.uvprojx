# Keil uVision project Project.uvprojx, settings and files
target STM32F103ZET6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --output .\bin\ZET6bin\zet6FW.bin .\Objects\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,LV_DISABLE_API_MAPPING,LV_CONF_INCLUDE_SIMPLE
  c include: .\Core;.\Core\Device\STM32F103C8T6;.\Core\Device\STM32F103C8T6\C8T6 STARTUP;.\Core\Device\STM32F103ZET6;.\Core\Device\STM32F103ZET6\ZET6 STARTUP;.\Driver\BSP;.\Driver\HAL\Inc;.\Driver\HAL\Inc\Legacy;.\Driver\HAL;.\Usr\Inc;.\HardWare;.\Driver\FreeRTOS\inc;.\Driver\FreeRTOS\port;.\Driver\FreeRTOS;.\deviceselcet;.\Driver\LVGL\src;.\Driver\LVGL
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\sct\ZET6\ProjectZET6.sct
  group Core
    ./Core/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm3.h
  group Core/Device/ZET6
    ./Core/Device/STM32F103ZET6/: stm32f1xx.h stm32f103xe.h system_stm32f1xx.c system_stm32f1xx.h
  group Core/Device/C8T6
    ./Core/Device/STM32F103C8T6/: stm32f1xx.h stm32f103xb.h system_stm32f1xx.c system_stm32f1xx.h
  group STARTUP_ZET6
    ./Core/Device/STM32F103ZET6/ZET6 STARTUP/: startup_stm32f103xe.s
  group STARTUP_C8T6
    ./Core/Device/STM32F103C8T6/C8T6 STARTUP/: startup_stm32f103xb.s
  group Driver/BSP
    ./Driver/BSP/: debug_uart.c debug_uart.h sys.c sys.h
  group Driver/HAL/Inc
    ./Driver/HAL/Inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_cec.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_mmc.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_adc.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_crc.h stm32f1xx_ll_dac.h stm32f1xx_ll_dma.h stm32f1xx_ll_exti.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_gpio.h stm32f1xx_ll_i2c.h stm32f1xx_ll_iwdg.h stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.h stm32f1xx_ll_rtc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_tim.h stm32f1xx_ll_usart.h stm32f1xx_ll_usb.h stm32f1xx_ll_utils.h stm32f1xx_ll_wwdg.h
    ./Driver/HAL/Inc/Legacy/: stm32_hal_legacy.h stm32f1xx_hal_can_ex_legacy.h stm32f1xx_hal_can_legacy.h
  group Driver/HAL_Src
    ./Driver/HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group Driver/HAL/Conf
    ./Driver/HAL/: stm32f1xx_hal_conf.h
  group HardWare
    ./HardWare/: Cus_Flash.c Cus_Flash.h sensor_data.h CAN_Cus.c CAN_Cus.h Cus_CAN_IT.c Cus_CAN_IT.h Cus_CANTP.c Cus_CANTP.h Cus_CANTP_cfg.c Cus_CANTP_cfg.h
  group Hardware/ymodem
    ./HardWare/ymodem/: common.c common.h ymodem.c ymodem.h flash_if.c flash_if.h
  group Usr/Inc
    ./Usr/Inc/: main.h stm32f1xx_it.h
  group Usr/Src
    ./Usr/Src/: main.c stm32f1xx_it.c
  group Usr/C8T6_Inc
    ./Usr/Inc_C8T6/: stm32f1xx_it.h c8t6_main.h sensor_param_sim.h sensor_param_simConf.h
  group Usr/C8T6_Src
    ./Usr/Src_C8T6/: stm32f1xx_it.c c8t6_main.c sensor_param_sim.c
  group Driver/FreeRTOS/Src
    ./Driver/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Driver/FreeRTOS/Inc
    ./Driver/FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Driver/FreeRTOS/Port
    ./Driver/FreeRTOS/port/: heap_4.c port.c portmacro.h
  group Driver/FreeRTOS/Conf
    ./Driver/FreeRTOS/: FreeRTOSConfig.h
  group DeviceSelect
    ./deviceselcet/: ds.h
  group Driver/LVGL/Src/core
    ./Driver/LVGL/src/core/: lv_global.h lv_group.c lv_group.h lv_group_private.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_class_private.h lv_obj_draw.c lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.c lv_obj_event.h lv_obj_event_private.h lv_obj_id_builtin.c lv_obj_pos.c lv_obj_pos.h lv_obj_private.h lv_obj_property.c lv_obj_property.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.c lv_obj_tree.h lv_observer.c lv_observer.h lv_observer_private.h lv_refr.c lv_refr.h lv_refr_private.h
  group Driver/LVGL/Src/widgets
    ./Driver/LVGL/src/widgets/3dtexture/: lv_3dtexture.c lv_3dtexture.h lv_3dtexture_private.h
    ./Driver/LVGL/src/widgets/animimage/: lv_animimage.c lv_animimage.h lv_animimage_private.h
    ./Driver/LVGL/src/widgets/arc/: lv_arc.c lv_arc.h lv_arc_private.h
    ./Driver/LVGL/src/widgets/arclabel/: lv_arclabel.c lv_arclabel.h lv_arclabel_private.h
    ./Driver/LVGL/src/widgets/bar/: lv_bar.c lv_bar.h lv_bar_private.h
    ./Driver/LVGL/src/widgets/button/: lv_button.c lv_button.h lv_button_private.h
    ./Driver/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
    ./Driver/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_chinese.c lv_calendar_chinese.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h lv_calendar_private.h
    ./Driver/LVGL/src/widgets/canvas/: lv_canvas.c lv_canvas.h lv_canvas_private.h
    ./Driver/LVGL/src/widgets/chart/: lv_chart.c lv_chart.h lv_chart_private.h
    ./Driver/LVGL/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
    ./Driver/LVGL/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
    ./Driver/LVGL/src/widgets/gif/: lv_gif.c lv_gif.h
    ./Driver/LVGL/src/widgets/image/: lv_image.c lv_image.h lv_image_private.h
    ./Driver/LVGL/src/widgets/imagebutton/: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
    ./Driver/LVGL/src/widgets/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
    ./Driver/LVGL/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
    ./Driver/LVGL/src/widgets/label/: lv_label.c lv_label.h lv_label_private.h
    ./Driver/LVGL/src/widgets/led/: lv_led.c lv_led.h lv_led_private.h
    ./Driver/LVGL/src/widgets/line/: lv_line.c lv_line.h lv_line_private.h
    ./Driver/LVGL/src/widgets/list/: lv_list.c lv_list.h
    ./Driver/LVGL/src/widgets/lottie/: lv_lottie.c lv_lottie.h lv_lottie_private.h
    ./Driver/LVGL/src/widgets/menu/: lv_menu.c lv_menu.h lv_menu_private.h
    ./Driver/LVGL/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
    ./Driver/LVGL/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
    ./Driver/LVGL/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_obj_property_names.h lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_style_properties.h lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ./Driver/LVGL/src/widgets/roller/: lv_roller.c lv_roller.h lv_roller_private.h
    ./Driver/LVGL/src/widgets/scale/: lv_scale.c lv_scale.h lv_scale_private.h
    ./Driver/LVGL/src/widgets/slider/: lv_slider.c lv_slider.h lv_slider_private.h
    ./Driver/LVGL/src/widgets/span/: lv_span.c lv_span.h lv_span_private.h
    ./Driver/LVGL/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
    ./Driver/LVGL/src/widgets/spinner/: lv_spinner.c lv_spinner.h lv_spinner_private.h
    ./Driver/LVGL/src/widgets/switch/: lv_switch.c lv_switch.h lv_switch_private.h
    ./Driver/LVGL/src/widgets/table/: lv_table.c lv_table.h lv_table_private.h
    ./Driver/LVGL/src/widgets/tabview/: lv_tabview.c lv_tabview.h lv_tabview_private.h
    ./Driver/LVGL/src/widgets/textarea/: lv_textarea.c lv_textarea.h lv_textarea_private.h
    ./Driver/LVGL/src/widgets/tileview/: lv_tileview.c lv_tileview.h lv_tileview_private.h
    ./Driver/LVGL/src/widgets/win/: lv_win.c lv_win.h lv_win_private.h
  group Driver/LVGL/Src/themes
    ./Driver/LVGL/src/themes/default/: lv_theme_default.c lv_theme_default.h
    ./Driver/LVGL/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ./Driver/LVGL/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
    ./Driver/LVGL/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
  group Driver/LVGL/Src/draw
    ./Driver/LVGL/src/draw/: lv_draw.c lv_draw.h lv_draw_3d.c lv_draw_3d.h lv_draw_arc.c lv_draw_arc.h lv_draw_blur.c lv_draw_blur.h lv_draw_buf.c lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.c lv_draw_image.h lv_draw_image_private.h lv_draw_label.c lv_draw_label.h lv_draw_label_private.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_private.h lv_draw_rect.c lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.c lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.c lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
    ./Driver/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_grad.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_mask_rect.c lv_draw_sw_private.h lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_utils.h lv_draw_sw_vector.c
    ./Driver/LVGL/src/draw/convert/: lv_draw_buf_convert.c lv_draw_buf_convert.h
    ./Driver/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_a8.h lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888_premultiplied.h lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565_swapped.h lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb888.h
  group Driver/LVGL/Src/display
    ./Driver/LVGL/src/display/: lv_display.c lv_display.h lv_display_private.h
  group Driver/LVGL/Src/font
    ./Driver/LVGL/src/font/: lv_font.c lv_font.h lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_private.h lv_symbol_def.h
    ./Driver/LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_fmt_txt_private.h
    ./Driver/LVGL/src/font/imgfont/: lv_imgfont.c lv_imgfont.h
    ./Driver/LVGL/src/font/binfont_loader/: lv_binfont_loader.c lv_binfont_loader.h
  group Driver/LVGL/Src/misc
    ./Driver/LVGL/src/misc/: lv_anim.c lv_anim.h lv_anim_private.h lv_anim_timeline.c lv_anim_timeline.h lv_anim_timeline_private.h lv_area.c lv_area.h lv_area_private.h lv_array.c lv_array.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_bidi_private.h lv_check_arg.h lv_circle_buf.c lv_circle_buf.h lv_color.c lv_color.h lv_color_op.c lv_color_op.h lv_color_op_private.h lv_event.c lv_event.h lv_event_private.h lv_ext_data.h lv_fs.c lv_fs.h lv_fs_private.h lv_grad.c lv_grad.h lv_iter.c lv_iter.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_matrix.c lv_matrix.h lv_palette.c lv_palette.h lv_pending.c lv_pending.h lv_profiler.h lv_profiler_builtin.c lv_profiler_builtin.h lv_profiler_builtin_posix.c lv_profiler_builtin_private.h lv_rb.c lv_rb.h lv_rb_private.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_style_private.h lv_templ.c lv_templ.h lv_text.c lv_text.h lv_text_ap.c lv_text_ap.h lv_text_private.h lv_timer.c lv_timer.h lv_timer_private.h lv_tree.c lv_tree.h lv_types.h lv_utils.c lv_utils.h
  group Driver/LVGL/Src/osal
    ./Driver/LVGL/src/osal/: lv_freertos.c lv_freertos.h lv_os.c lv_os.h
  group Driver/LVGL/Src/stdlib
    ./Driver/LVGL/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
    ./Driver/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ./Driver/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
    ./Driver/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
  group Driver/LVGL/Src/tick
    ./Driver/LVGL/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
  group Driver/LVGL/Src/init
    ./Driver/LVGL/src/: lv_init.c lv_init.h
  group Driver/LVGL/Src/indev
    ./Driver/LVGL/src/indev/: lv_gridnav.c lv_gridnav.h lv_indev.c lv_indev.h lv_indev_gesture.c lv_indev_gesture.h lv_indev_gesture_private.h lv_indev_private.h lv_indev_scroll.c lv_indev_scroll.h
  group Driver/LVGL/Src/cache
    ./Driver/LVGL/src/misc/cache/: lv_cache.c lv_cache.h lv_cache_entry.c lv_cache_entry.h lv_cache_entry_private.h lv_cache_private.h
    ./Driver/LVGL/src/misc/cache/instance/: lv_cache_instance.h lv_image_cache.c lv_image_cache.h lv_image_header_cache.c lv_image_header_cache.h
    ./Driver/LVGL/src/misc/cache/class/: lv_cache_class.h lv_cache_lru_ll.c lv_cache_lru_ll.h lv_cache_lru_rb.c lv_cache_lru_rb.h lv_cache_sc_da.c lv_cache_sc_da.h
  group Driver/LVGL/Src/layout
    ./Driver/LVGL/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
    ./Driver/LVGL/src/layouts/flex/: lv_flex.c lv_flex.h
    ./Driver/LVGL/src/layouts/grid/: lv_grid.c lv_grid.h
  group Driver/LVGL/port
    ./Driver/LVGL/port/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group Bootloader
    ./Bootloader/: Bootloader.c Bootloader.h Bootloader_Utils.c Bootloader_Utils.h BootloaderConf.h stm32f1xx_it_bootloader.c stm32f1xx_it_bootloader.h main.c main.h crc32table.c crc32table.h
target STM32F103C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf.exe --bin --output .\bin\C8T6bin\c8t6FW.bin .\Objects\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\Core;.\Core\Device\STM32F103C8T6;.\Core\Device\STM32F103C8T6\C8T6 STARTUP;.\Core\Device\STM32F103ZET6;.\Core\Device\STM32F103ZET6\ZET6 STARTUP;.\Driver\BSP;.\Driver\HAL\Inc;.\Driver\HAL\Inc\Legacy;.\Driver\HAL;.\HardWare;.\deviceselcet;.\Usr\Inc_C8T6;.\HardWare\ymodem
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\sct\C8T6\ProjectC8T6.sct
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin --output .\bin\Bootloader\boot.bin .\Objects\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\Core;.\Core\Device\STM32F103C8T6;.\Core\Device\STM32F103C8T6\C8T6 STARTUP;.\Core\Device\STM32F103ZET6;.\Core\Device\STM32F103ZET6\ZET6 STARTUP;.\Driver\BSP;.\Driver\HAL\Inc;.\Driver\HAL\Inc\Legacy;.\Driver\HAL;.\Usr\Inc;.\HardWare;.\deviceselcet
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\sct\Bootloader\Bootloader.sct
